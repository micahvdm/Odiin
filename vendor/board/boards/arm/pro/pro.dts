/*
 * Copyright (c) 2020 makerdiary
 * Copyright (c) 2017 Linaro Limited
 *
 * SPDX-License-Identifier: Apache-2.0
 */

/dts-v1/;
#include <nordic/nrf52840_qiaa.dtsi>

/ {
	model = "Makerdiary nRF52840-M2 Module";
	compatible = "nordic,nrf52840-dk-nrf52840";

	chosen {
		zephyr,console = &uart0;
		zephyr,shell-uart = &uart0;
		zephyr,uart-mcumgr = &uart0;
		zephyr,bt-mon-uart = &uart0;
		zephyr,bt-c2h-uart = &uart0;
		zephyr,sram = &sram0;
		zephyr,flash = &flash0;
		zephyr,code-partition = &slot0_partition;
	};

	arduino_header: connector {
		compatible = "arduino-header-r3";
		#gpio-cells = <2>;
		gpio-map-mask = <0xffffffff 0xffffffc0>;
		gpio-map-pass-thru = <0 0x3f>;
		gpio-map = <0 0 &gpio0 8 0>      /* D0 */
            , <1 0 &gpio0 6 0>      /* D1 */
            , <2 0 &gpio0 17 0>     /* D2 */
            , <3 0 &gpio0 20 0>     /* D3 */
            , <4 0 &gpio0 22 0>     /* D4/A6 */
            , <5 0 &gpio0 24 0>     /* D5 */
            , <6 0 &gpio1 0 0>      /* D6/A7 */
            , <7 0 &gpio0 11 0>     /* D7 */
            , <8 0 &gpio1 4 0>      /* D8/A8 */
            , <9 0 &gpio1 6 0>      /* D9/A9 */
            , <14 0 &gpio1 11 0>    /* D14 */
            , <15 0 &gpio1 13 0>    /* D15 */
            , <18 0 &gpio1 15 0>    /* D18/A0 */
            , <19 0 &gpio0 2 0> /* D19/A1 */
            , <20 0 &gpio0 29 0>    /* D20/A2 */
            , <21 0 &gpio0 31 0>    /* D21/A3 */
	};
	arduino_adc: analog-connector {
		compatible = "arduino,uno-adc";
		#io-channel-cells = <1>;
		io-channel-map = <0 0 &gpio1 15 0> /* D18/A0 */
            , <1 0 &gpio0 2 0>  /* D19/A1 */
            , <2 0 &gpio0 29 0> /* D20/A2 */
            , <3 0 &gpio0 31 0> /* D21/A3 */
            , <6 0 &gpio0 22 0> /* D4/A6 */
            , <7 0 &gpio1 0 0>  /* D6/A7 */
            , <8 0 &gpio1 4 0>  /* D8/A8 */
            , <9 0 &gpio1 6 0>  /* D9/A9 */
	};

&adc {
	status = "okay";
};

&gpiote {
	status = "okay";
};

&gpio0 {
	status = "okay";
};

&gpio1 {
	status = "okay";
};

&uart0 {
	compatible = "nordic,nrf-uart";
	status = "okay";
	current-speed = <115200>;
	tx-pin = <16>;
	rx-pin = <15>;
	rts-pin = <14>;
	cts-pin = <13>;
};

arduino_i2c: &i2c0 {
	compatible = "nordic,nrf-twi";
	status = "okay";
	sda-pin = <37>;
	scl-pin = <38>;
};

&i2c1 {
	compatible = "nordic,nrf-twi";
	/* status = "okay"; */
	sda-pin = <26>;
	scl-pin = <27>;
};

&pwm0 {
	status = "okay";
	ch0-pin = <30>;
	ch0-inverted;
	ch1-pin = <29>;
	ch1-inverted;
	ch2-pin = <31>;
	ch2-inverted;
	ch3-pin = <20>;
};

arduino_spi: &spi1 {
	compatible = "nordic,nrf-spi";
	/* status = "okay"; */
	sck-pin = <39>;
	mosi-pin = <35>;
	miso-pin = <36>;
	cs-gpios = <&arduino_header 16 0>; /* D10 */
};

&spi2 {
	compatible = "nordic,nrf-spi";
	/* Cannot be used together with i2c1. */
	status = "okay";
	sck-pin = <27>;
	mosi-pin = <26>;
	miso-pin = <28>;
};

&spi0 {
	compatible = "nordic,nrf-spi";
	status = "okay";
	sck-pin = <11>;
	mosi-pin = <12>;
	miso-pin = <40>;
	cs-gpios = <&gpio0 6 0>,<&gpio0 7 0>;

	st7789v@0 {
		compatible = "sitronix,st7789v";
		label = "DISPLAY";
		spi-max-frequency = <20000000>;
		reg = <0>;
		cmd-data-gpios = <&gpio0 8 GPIO_ACTIVE_LOW>;
		reset-gpios = <&gpio1 9 GPIO_ACTIVE_LOW>;
		width = <240>;
		height = <240>;
		x-offset = <80>;
		y-offset = <0>;
		vcom = <0x19>;
		gctrl = <0x35>;
		vrhs = <0x12>;
		vdvs = <0x20>;
		mdac = <0xa0>;
		gamma = <0x01>;
		colmod = <0x05>;
		lcm = <0x2c>;
		porch-param = [0c 0c 00 33 33];
		cmd2en-param = [5a 69 02 01];
		pwctrl1-param = [a4 a1];
		pvgam-param = [D0 04 0D 11 13 2B 3F 54 4C 18 0D 0B 1F 23];
		nvgam-param = [D0 04 0C 11 13 2C 3F 44 51 2F 1F 1F 20 23];
		ram-param = [00 F0];
		rgb-param = [CD 08 14];
	};

	sdhc0: sdhc@1 {
		compatible = "zephyr,mmc-spi-slot";
		reg = <1>;
		status = "okay";
		label = "SDHC0";
		spi-max-frequency = <24000000>;
	};
};


&qspi {
	status = "okay";
	sck-pin = <43>;
	io-pins = <42>, <46>, <47>, <44>;
	csn-pins = <45>;
	mx25r64: mx25r6435f@0 {
		compatible = "nordic,qspi-nor";
		reg = <0>;
		writeoc = "pp4io";
		readoc = "read4io";
		sck-frequency = <8000000>;
		label = "MX25R64";
		jedec-id = [c2 28 17];
		size = <67108864>;
		has-be32k;
		has-dpd;
		t-enter-dpd = <10000>;
		t-exit-dpd = <35000>;
	};
};


/* Include flash partition table.
 * Two partition tables are available:
 * fstab-stock		-compatible with Nordic nRF5 bootloader, default
 * fstab-debugger	-to use an external debugger, w/o the nRF5 bootloader
 *
 * For more information, see:
 * http://docs.zephyrproject.org/latest/guides/dts/index.html#flash-partitions
 */
#include "fstab-stock.dts"

&usbd {
	compatible = "nordic,nrf-usbd";
	status = "okay";
};
